/*
*
* Copyright (c) 2025 Rafael Romão
* SPDX-License-Identifier: MIT
*
*/

/*
 * LEGACY VIM MODE
 *
 * Everything in this file exists only for legacy mode: the host knows that a
 * vim-like editor is focused but not which mode it is in, so it sends code 4
 * and the keyboard infers the mode by itself from the keys pressed. Neovim
 * needs none of this -- its plugin reports the real mode and the host drives
 * the layers directly through the codes in vim.dtsi.
 *
 * Legacy mode is entered:
 *   - from the host, with `zmk-vim-mode set legacy` (code 4) or whenever a
 *     legacy app such as VSCode or Obsidian is focused;
 *   - by hand, with the cb_vim_mode combo (LTR LTM LTI) or cb_enter_vim on
 *     the MACROS layer. Both send Hyper+Esc, which the host binds to
 *     `set legacy --sticky`, so the daemon learns about it.
 * It is left by hand with cb_leave_vim (MACROS), which sends Meh+Esc, bound
 * on the host to `set off --sticky`.
 *
 * Once every editor reports its mode, delete this file, its #include in
 * definitions/includes.h and the two bindings in the host's
 * contrib/hyprland-bind.conf. Nothing else references what is defined here;
 * the build will tell you if that ever changes.
 *
 * This file must be included last: it extends the vim_sync and combos nodes,
 * whose labels have to exist before they can be referenced.
 */

/ {
    vim_legacy {
        /*
         * Enter/leave by hand. vim_mode_on is a layer-morph so that, when a
         * vim layer is already active, the combo does nothing instead of
         * injecting a second Esc.
         */
        VIM_MACRO(vim_reset_notify      , &vim_reset &kp LG(LC(LA(LS(ESC)))))
        VIM_MACRO(vim_mode_off          , &vim_off &kp LC(LA(LS(ESC))))
        VIM_BINDING(vim_mode_on         , VIM_NORMAL VIM_VISUAL VIM_CHANGE VIM_INSERT VIM_REPLACE VIM_CMDLINE, &none, &vim_reset_notify)

        /*
         * Entry driven by the host (code 4). It must NOT reuse vim_mode_on:
         * the listener clears every managed layer before running a code's
         * bindings, so the layer-morph above would always find no vim layer
         * active and always send Hyper+Esc -- which the host binds to
         * `set legacy`, toggling its own override straight back off.
         *
         * The Esc is deliberate: it puts the editor's own vim into normal
         * mode, so it agrees with the NORMAL layer the code just selected.
         */
        VIM_MACRO(vim_mode_on_host      , &kp ESC)
    };
};

/*
 * Host codes that only make sense while the keyboard infers modes on its own.
 * Code 7 is code 4 without the Esc: the host uses it to re-assert legacy mode
 * after a reconnect or a clobber, so the Esc is never replayed.
 */
&vim_sync {
    legacy        { code = <4>; layers = <VIM_NORMAL>; bindings = <&vim_mode_on_host>; };
    legacy_silent { code = <7>; layers = <VIM_NORMAL>; };
};

&combos {
    COMBO(cb_vim_mode,      LTR LTM LTI,     &vim_mode_on,           ALPHA1_LAYERS VIM_LAYERS)
    COMBO(cb_enter_vim,     RTI RTM,         &vim_mode_on,           MACROS)
    COMBO(cb_leave_vim,     RTM RTR,         &vim_mode_off,          MACROS)
};
