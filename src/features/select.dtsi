/*
*
* Copyright (c) 2022 Rafael Romão
* SPDX-License-Identifier: MIT
*
*/

/ {
    select {
        
        // Select Home

        select_home: select_home {
            compatible = "zmk,behavior-macro";
            #binding-cells = <0>;
            wait-ms = <10>;
            tap-ms = <0>;
            bindings = <&macro_tap &kp LS(HOME)>;
        };

        // Select Word

        OS_MORPH(mc_sel1w, \
            &macro_tap &kp LA(LEFT) &kp LA(RIGHT) &macro_press &kp LA(LS(LEFT)) &macro_pause_for_release &macro_release &kp LA(LS(LEFT)), \
            &macro_tap &kp LC(LEFT) &kp LC(RIGHT) &macro_press &kp LC(LS(LEFT)) &macro_pause_for_release &macro_release &kp LC(LS(LEFT))>
        )
        OS_MORPH(mc_selpw, \
            &macro_press &kp LA(LS(LEFT)) &macro_pause_for_release &macro_release &kp LA(LS(LEFT)),
            &macro_press &kp LC(LS(LEFT)) &macro_pause_for_release &macro_release &kp LC(LS(LEFT))
        )
        OS_MORPH(mc_selcw, \
            LA(LS(LEFT)),
            LC(LS(LEFT))
        )

        select_word: select_word {
            compatible = "zmk,behavior-adaptive-key";
            #binding-cells = <0>;
            bindings = <&mc_sel1w>;

            ADAPTIVE(cont_sel_word, &mc_selpw, &mc_selcw)
        };

        //Select Line

        mc_sel1ln: mc_sel1ln {
            compatible = "zmk,behavior-macro";
            #binding-cells = <0>;
            wait-ms = <0>;
            tap-ms = <0>;
            bindings = <&macro_tap &kp HOME &kp HOME &kp LS(END)>;
        };
        mc_selnln: mc_selnln {
            compatible = "zmk,behavior-macro";
            #binding-cells = <0>;
            wait-ms = <0>;
            tap-ms = <0>;
            bindings = <&macro_tap &kp LS(DOWN) &kp LS(END)>;
        };
        select_line: select_line {
            compatible = "zmk,behavior-adaptive-key";
            #binding-cells = <0>;
            bindings = <&mc_sel1ln>;

            ADAPTIVE(cont_sel_line, &mc_selnln, LS(END))
        };

   };
};
